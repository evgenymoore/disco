# IAR project Backup of discovery.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F3xx; STM32F303xC; STM32F30xC
  ICCARM.CCIncludePath2: ..\inc; STM32CubeF3\Drivers\CMSIS\Device\ST\STM32F3xx\Include; STM32CubeF3\Drivers\CMSIS\Include; STM32CubeF3\Drivers\STM32F3xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: discovery.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: STM32CubeF3\Drivers\CMSIS\Device\ST\STM32F3xx\Source\Templates\iar\linker\stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: gpio.c gyro.c main.c stm32f3xx_it.c tim.c
    STM32CubeF3/Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f303xc.s
    STM32CubeF3/Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
